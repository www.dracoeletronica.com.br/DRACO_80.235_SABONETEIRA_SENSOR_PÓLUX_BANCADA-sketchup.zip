Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_80.235_SABONETEIRA_SENSOR_PÓLUX_BANCADA.IFC
Time: 2022-12-06T14:58:44
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_80.235_SABONETEIRA_SENSOR_PÓLUX_BANCADA
In: Default Storey
Material: Steel
